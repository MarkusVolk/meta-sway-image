DEPENDS:class-target += " freeglut"

PACKAGECONFIG:append:class-target = " webp zstd libdeflate"
