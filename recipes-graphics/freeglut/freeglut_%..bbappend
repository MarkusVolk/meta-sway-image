PACKAGECONFIG:append = " gles"

